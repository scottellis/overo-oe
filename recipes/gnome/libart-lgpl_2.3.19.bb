require libart-lgpl.inc

PR = "r3"

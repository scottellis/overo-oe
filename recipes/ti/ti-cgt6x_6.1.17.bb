require ti-cgt6x.inc

PE = "1"
PV = "6_1_17"
PVwithdots = "6.1.17"

SRC_URI[cgt6xbin.md5sum] = "5ee5c8e573ab0a1ba1249511d4a06c27"
SRC_URI[cgt6xbin.sha256sum] = "0cb99e755f5d06a74db22d7c814e4dfd36aa5fcb35eeab01ddb000aef99c08c1"
